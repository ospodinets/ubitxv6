#include "toneAC2/toneAC2.h"
#include "pin_definitions.h"
#include "ptt.h"
#include "settings.h"
#include "tuner.h"
#include "tx_manager.h"

/**
 * The CW keyer uses independent dot and dash inputs.
 * The sidetone is generated by the Arduino and injected into the volume control.
 */

/**
 * Starts transmitting the carrier with the sidetone
 * It assumes that we have called cwTxStart and not called cwTxStop
 * each time it is called, the cwTimeOut is pushed further into the future
 */
void cwKeydown(){
  toneAC2(PIN_CW_TONE, globalSettings.cwSideToneFreq);
  digitalWrite(PIN_CW_KEY, 1);

  txCwTailRestart();
}

/**
 * Stops the cw carrier transmission along with the sidetone
 * Pushes the cwTimeout further into the future
 */
void cwKeyUp(){
  noToneAC2();
  digitalWrite(PIN_CW_KEY, 0);
  
  txCwTailRestart();
}

//Variables for Ron's new logic
#define DIT_L 0x01 // DIT latch
#define DAH_L 0x02 // DAH latch
#define DIT_PROC 0x04 // DIT is being processed
#define PDLSWAP 0x08 // 0 for normal, 1 for swap
#define IAMBICB 0x10 // 0 for Iambic A, 1 for Iambic B
enum KSTYPE {IDLE, CHK_DIT, CHK_DAH, KEYED_PREP, KEYED, INTER_ELEMENT };
static uint32_t keyerElementDurationMs = 0;//Length of the element being prepared
static uint32_t keyerDeadlineMs = 0;//End of the element or inter-element gap being timed
static KSTYPE keyerState = IDLE;
static uint8_t keyerControl = 0;
static bool straightKeyDown = false;

static bool cwPracticeActive = false;
static uint8_t cwPracticeSegment = 0;
static bool cwPracticeToneOn = false;
static unsigned int cwPracticeFrequency = 0;
static uint16_t cwPracticeDitDurationMs = 0;
static unsigned long cwPracticeNextChangeMs = 0;

void startCwPractice(const uint16_t frequency, const uint16_t ditDurationMs)
{
  if (cwPracticeActive) {
    cwPracticeFrequency = frequency;
    cwPracticeDitDurationMs = ditDurationMs;
    if (cwPracticeToneOn) {
      toneAC2(PIN_CW_TONE, cwPracticeFrequency);
    }
    return;
  }

  cwPracticeFrequency = frequency;
  cwPracticeDitDurationMs = ditDurationMs;
  cwPracticeSegment = 0;
  cwPracticeActive = true;
  cwPracticeToneOn = true;
  toneAC2(PIN_CW_TONE, cwPracticeFrequency);
  cwPracticeNextChangeMs = millis() + cwPracticeDitDurationMs;
}

void stopCwPractice()
{
  if (cwPracticeActive) {
    noToneAC2();
    cwPracticeActive = false;
    cwPracticeToneOn = false;
  }
}

void updateCwPractice()
{
  const unsigned long now = millis();
  if (!cwPracticeActive
      || static_cast<long>(now - cwPracticeNextChangeMs) < 0) {
    return;
  }

  cwPracticeSegment = (cwPracticeSegment + 1) % 8;
  cwPracticeToneOn = cwPracticeSegment % 2 == 0;
  if (cwPracticeToneOn) {
    toneAC2(PIN_CW_TONE, cwPracticeFrequency);
  } else {
    noToneAC2();
  }

  const bool characterGap = cwPracticeSegment == 7;
  const bool dah = cwPracticeToneOn && cwPracticeSegment == 6;
  const unsigned long durationMultiplier = characterGap || dah ? 3 : 1;
  cwPracticeNextChangeMs = now + durationMultiplier * cwPracticeDitDurationMs;
}

struct DebouncedInput {
  int rawState;
  int stableState;
  unsigned long changedAt;
};

static const unsigned long PADDLE_DEBOUNCE_MS = 5;

bool readPaddlePressed(const uint32_t pin, DebouncedInput* const input) {
  const int rawState = digitalRead(pin);
  const unsigned long now = millis();
  if (rawState != input->rawState) {
    input->rawState = rawState;
    input->changedAt = now;
  } else if (input->stableState != input->rawState
             && now - input->changedAt >= PADDLE_DEBOUNCE_MS) {
    input->stableState = input->rawState;
  }
  return input->stableState == LOW;
}

uint8_t update_PaddleLatch(bool isUpdateKeyState) {
  static DebouncedInput ditInput = {HIGH, HIGH, 0};
  static DebouncedInput dahInput = {HIGH, HIGH, 0};
  uint8_t tmpKeyerControl = 0;

  if (readPaddlePressed(PIN_KEYER_DIT, &ditInput))
    tmpKeyerControl |= DIT_L;
  if (readPaddlePressed(PIN_KEYER_DAH, &dahInput))
    tmpKeyerControl |= DAH_L;

  if (isUpdateKeyState)
    keyerControl |= tmpKeyerControl;

  return tmpKeyerControl;
}

/*****************************************************************************
// New logic, by RON
// modified by KD8CEC
******************************************************************************/
static bool deadlineReached(const uint32_t nowMs, const uint32_t deadlineMs)
{
  return static_cast<int32_t>(nowMs - deadlineMs) >= 0;
}

//Straight key mode uses DIT; PTT is also accepted as a CW key for tune up and quick QSOs
static void straightKeyUpdate(const uint32_t nowMs)
{
  const bool keyPressed = (update_PaddleLatch(false) & DIT_L) || IsPttPressed();

  if (keyPressed){
    if (!straightKeyDown){
      if (TxSource::CwKey != txSource()){
        txStart(TxSource::CwKey);//Fails while another source owns TX, so just try again next pass
        return;//Key down on the next pass, once the main loop has updated the display
      }
      cwKeydown();
      straightKeyDown = true;
    }
  }
  else if (straightKeyDown){
    cwKeyUp();
    straightKeyDown = false;
  }
  else{
    txStopIfCwTailExpired(nowMs);//Only while idle, so a character is never cut short
  }
}

//Performs one state transition at most, and never waits for a timer or a paddle
static void iambicKeyerUpdate(const uint32_t nowMs)
{
  switch(keyerState){
    case IDLE:
    {
      const uint8_t tmpKeyControl = update_PaddleLatch(false);
      if((tmpKeyControl == DAH_L)//Currently dah
       ||(tmpKeyControl == DIT_L)//Currently dit
       ||(tmpKeyControl == (DAH_L | DIT_L))//Currently both
       ||( keyerControl  & (DAH_L | DIT_L))){//Resolving either
        update_PaddleLatch(true);
        keyerState = CHK_DIT;
      }
      else{
        txStopIfCwTailExpired(nowMs);//Only while idle, so a character is never cut short
      }
      break;
    }

    case CHK_DIT:
      if (keyerControl & DIT_L) {
        keyerControl |= DIT_PROC;
        keyerElementDurationMs = globalSettings.cwDitDurationMs;
        keyerState = KEYED_PREP;
      }else{
        keyerState = CHK_DAH;
      }
      break;

    case CHK_DAH:
      if (keyerControl & DAH_L) {
        keyerElementDurationMs = 3*globalSettings.cwDitDurationMs;
        keyerState = KEYED_PREP;
      }else{
        keyerState = IDLE;
      }
      break;

    case KEYED_PREP:
      //modified KD8CEC
      if (TxSource::CwKey != txSource()){
        txStart(TxSource::CwKey);//Fails while another source owns TX, so just try again next pass
        break;//Key down on the next pass, once the main loop has updated the display
      }
      keyerControl &= ~(DIT_L + DAH_L); // clear both paddle latch bits
      cwKeydown();
      //Time from the moment the key went down, since starting TX can take a while
      keyerDeadlineMs = millis() + keyerElementDurationMs;
      keyerState = KEYED; // next state
      break;

    case KEYED:
      if (deadlineReached(nowMs, keyerDeadlineMs)) { // are we at end of key down ?
        cwKeyUp();
        keyerDeadlineMs = millis() + globalSettings.cwDitDurationMs; // inter-element time
        keyerState = INTER_ELEMENT; // next state
      }
      else if(KeyerMode_e::KEYER_IAMBIC_B == globalSettings.keyerMode){
        update_PaddleLatch(true); // early paddle latch in Iambic B mode
      }
      break;

    case INTER_ELEMENT:
      // Insert time between dits/dahs
      update_PaddleLatch(true); // latch paddle state
      if (deadlineReached(nowMs, keyerDeadlineMs)) { // are we at end of inter-space ?
        if (keyerControl & DIT_PROC) { // was it a dit or dah ?
          keyerControl &= ~(DIT_L + DIT_PROC); // clear two bits
          keyerState = CHK_DAH; // dit done, check for dah
        }else{
          keyerControl &= ~(DAH_L); // clear dah latch
          keyerState = IDLE; // go idle
        }
      }
      break;
  }
}

/*
 * Call this on every pass of the main loop. It never blocks, so the rest of the
 * firmware keeps running while keying; elements are timed against the clock.
 */
void cwKeyerUpdate(const uint32_t nowMs){
  //An element or key-down in progress is always finished in the mode it was started in
  const bool midElement = straightKeyDown || (IDLE != keyerState);
  const bool useStraightKey = straightKeyDown
    || (!midElement
        && ((KeyerMode_e::KEYER_STRAIGHT == globalSettings.keyerMode)
            || IsPttPressed()));//use the PTT as the key for tune up, quick QSOs

  if(useStraightKey){
    straightKeyUpdate(nowMs);
  }
  else{//KEYER_IAMBIC_*
    iambicKeyerUpdate(nowMs);
  }
}
